v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
N 530 -80 650 -80 {lab=out_comp_p_a}
N 530 -40 650 -40 {lab=out_comp_n_a}
N 710 -40 840 -40 {lab=out_comp_n_d}
N 710 -80 730 -80 {lab=out_comp_p_d}
N 730 -80 730 -60 {lab=out_comp_p_d}
N 730 -60 840 -60 {lab=out_comp_p_d}
N 1170 -340 1230 -340 {lab=#net1}
N 1170 -320 1230 -320 {lab=#net2}
N 1170 -280 1230 -280 {lab=#net3}
N 1170 -260 1230 -260 {lab=#net4}
N 1170 -240 1230 -240 {lab=#net5}
N 1170 -220 1230 -220 {lab=#net6}
N 1170 -200 1230 -200 {lab=#net7}
N 1170 -180 1230 -180 {lab=#net8}
N 1170 -160 1230 -160 {lab=#net9}
N 1170 -140 1230 -140 {lab=#net10}
N 1170 -120 1230 -120 {lab=#net11}
N 1170 -100 1230 -100 {lab=#net12}
N 1170 -80 1230 -80 {lab=#net13}
N 1170 -60 1230 -60 {lab=#net14}
N 1170 -40 1230 -40 {lab=#net15}
N 1170 -20 1230 -20 {lab=#net16}
N 1170 0 1230 0 {lab=#net17}
N 1170 20 1230 20 {lab=#net18}
N 1290 -340 1380 -340 {lab=phi_a}
N 1290 -320 1380 -320 {lab=phi_smp_inv_a}
N 1290 -280 1380 -280 {lab=dac_p_a7}
N 1290 -260 1380 -260 {lab=dac_p_a6}
N 1290 -240 1380 -240 {lab=dac_p_a5}
N 1290 -220 1380 -220 {lab=dac_p_a4}
N 1290 -200 1380 -200 {lab=dac_p_a3}
N 1290 -180 1380 -180 {lab=dac_p_a2}
N 1290 -160 1380 -160 {lab=dac_p_a1}
N 1290 -140 1380 -140 {lab=dac_p_a0}
N 1290 -120 1380 -120 {lab=dac_n_a7}
N 1290 -100 1380 -100 {lab=dac_n_a6}
N 1290 -80 1380 -80 {lab=dac_n_a5}
N 1290 -60 1380 -60 {lab=dac_n_a4}
N 1290 -40 1380 -40 {lab=dac_n_a3}
N 1290 -20 1380 -20 {lab=dac_n_a2}
N 1290 0 1380 0 {lab=dac_n_a1}
N 1290 20 1380 20 {lab=dac_n_a0}
N 130 -220 220 -220 {lab=VOUTP}
N 220 -220 220 -80 {lab=VOUTP}
N 220 -80 310 -80 {lab=VOUTP}
N 130 170 220 170 {lab=VOUTN}
N 220 -40 220 170 {lab=VOUTN}
N 220 -40 310 -40 {lab=VOUTN}
N -100 -370 -100 -300 {lab=VDD}
N -100 250 -100 330 {lab=VDD}
N 390 -210 390 -130 {lab=VDD}
N -80 -370 -80 -300 {lab=Vref}
N -80 250 -80 330 {lab=Vref}
N -20 -370 -20 -300 {lab=phi_a}
N 0 -340 0 -300 {lab=phi_smp_inv_a}
N -20 250 -20 360 {lab=phi_a}
N 0 250 0 320 {lab=phi_smp_inv_a}
N 840 -60 890 -60 {lab=out_comp_p_d}
N 840 -40 890 -40 {lab=out_comp_n_d}
N -50 -140 -50 -90 {lab=dac_p_a7}
N -30 -140 -30 -90 {lab=dac_p_a6}
N -10 -140 -10 -90 {lab=dac_p_a5}
N 10 -140 10 -90 {lab=dac_p_a4}
N 30 -140 30 -90 {lab=dac_p_a3}
N 50 -140 50 -90 {lab=dac_p_a2}
N 70 -140 70 -90 {lab=dac_p_a1}
N 90 -140 90 -90 {lab=dac_p_a0}
N -50 50 -50 90 {lab=dac_n_a7}
N -30 50 -30 90 {lab=dac_n_a6}
N -10 50 -10 90 {lab=dac_n_a5}
N 10 50 10 90 {lab=dac_n_a4}
N 30 50 30 90 {lab=dac_n_a3}
N 50 50 50 90 {lab=dac_n_a2}
N 70 50 70 90 {lab=dac_n_a1}
N 90 50 90 90 {lab=dac_n_a0}
N -260 -220 -170 -220 {lab=VIN_P}
N -270 170 -170 170 {lab=VIN_N}
N -100 -140 -100 -100 {lab=GND}
N -100 50 -100 90 {lab=GND}
N 390 10 390 50 {lab=GND}
N 710 -120 750 -120 {lab=rst_d}
N 750 -120 750 -80 {lab=rst_d}
N 750 -80 890 -80 {lab=rst_d}
N 710 -150 770 -150 {lab=clk_d}
N 770 -150 770 -100 {lab=clk_d}
N 770 -100 890 -100 {lab=clk_d}
N 610 -150 650 -150 {lab=clk}
N 610 -360 610 -150 {lab=clk}
N 570 -360 610 -360 {lab=clk}
N 590 -120 650 -120 {lab=rst_n}
N 590 -340 590 -120 {lab=rst_n}
N 570 -340 590 -340 {lab=rst_n}
N 1170 40 1230 40 {lab=#net19}
N 1170 60 1230 60 {lab=#net20}
N 1170 80 1230 80 {lab=#net21}
N 1170 100 1230 100 {lab=#net22}
N 1170 120 1230 120 {lab=#net23}
N 1170 140 1230 140 {lab=#net24}
N 1170 160 1230 160 {lab=#net25}
N 1170 180 1230 180 {lab=#net26}
N 1170 200 1230 200 {lab=#net27}
N 1290 40 1380 40 {lab=dout7}
N 1290 60 1380 60 {lab=dout6}
N 1290 80 1380 80 {lab=dout5}
N 1290 100 1380 100 {lab=dout4}
N 1290 120 1380 120 {lab=dout3}
N 1290 140 1380 140 {lab=dout2}
N 1290 160 1380 160 {lab=dout1}
N 1290 180 1380 180 {lab=dout0}
N 1290 200 1380 200 {lab=eoc}
N 1170 -300 1230 -300 {lab=#net28}
N 1290 -300 1380 -300 {lab=clk_comp}
N 290 -10 310 -10 {lab=clk_comp}
N 290 -10 290 90 {lab=clk_comp}
C {cdac_complete.sym} -20 -210 0 0 {name=x1}
C {strongarm.sym} 460 -60 0 0 {name=x2}
C {cdac_complete.sym} -20 160 2 1 {name=x3}
C {adc_bridge1.sym} 680 -80 0 0 {name=A1
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.7
in_high=1.1
}
C {adc_bridge1.sym} 680 -40 0 0 {name=A2
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.7
in_high=1.1
}
C {dac_bridge1.sym} 1260 -340 0 0 {name=A3
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 -320 0 0 {name=A4
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 -280 0 0 {name=A5
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 -260 0 0 {name=A6
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 -240 0 0 {name=A7
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 -220 0 0 {name=A8
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 -200 0 0 {name=A9
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 -180 0 0 {name=A10
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 -160 0 0 {name=A11
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 -140 0 0 {name=A12
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 -120 0 0 {name=A13
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 -100 0 0 {name=A14
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 -80 0 0 {name=A15
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 -60 0 0 {name=A16
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 -40 0 0 {name=A17
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 -20 0 0 {name=A18
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 0 0 0 {name=A19
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 20 0 0 {name=A20
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {lab_wire.sym} -100 -370 0 0 {name=p2 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -100 330 0 0 {name=p3 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 390 -210 0 0 {name=p4 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -80 -370 0 1 {name=p6 sig_type=std_logic lab=Vref}
C {lab_wire.sym} -80 330 0 1 {name=p7 sig_type=std_logic lab=Vref}
C {lab_wire.sym} 220 -220 0 0 {name=p8 sig_type=std_logic lab=VOUTP}
C {lab_wire.sym} 210 170 2 1 {name=p9 sig_type=std_logic lab=VOUTN}
C {lab_wire.sym} -20 -370 0 1 {name=p10 sig_type=std_logic lab=phi_a}
C {lab_wire.sym} 0 -340 0 1 {name=p11 sig_type=std_logic lab=phi_smp_inv_a}
C {lab_wire.sym} -20 360 0 1 {name=p12 sig_type=std_logic lab=phi_a}
C {lab_wire.sym} 0 320 0 1 {name=p13 sig_type=std_logic lab=phi_smp_inv_a}
C {lab_wire.sym} 640 -80 0 0 {name=p14 sig_type=std_logic lab=out_comp_p_a}
C {lab_wire.sym} 640 -40 2 1 {name=p16 sig_type=std_logic lab=out_comp_n_a}
C {lab_wire.sym} 870 -60 0 0 {name=p17 sig_type=std_logic lab=out_comp_p_d}
C {lab_wire.sym} 870 -40 2 1 {name=p18 sig_type=std_logic lab=out_comp_n_d}
C {lab_wire.sym} 1340 -340 0 1 {name=p19 sig_type=std_logic lab=phi_a}
C {lab_wire.sym} 1340 -320 0 1 {name=p20 sig_type=std_logic lab=phi_smp_inv_a}
C {lab_wire.sym} 1340 -280 0 1 {name=p21 sig_type=std_logic lab=dac_p_a7}
C {lab_wire.sym} 1340 -260 0 1 {name=p22 sig_type=std_logic lab=dac_p_a6}
C {lab_wire.sym} 1340 -240 0 1 {name=p23 sig_type=std_logic lab=dac_p_a5}
C {lab_wire.sym} 1340 -220 0 1 {name=p24 sig_type=std_logic lab=dac_p_a4}
C {lab_wire.sym} 1340 -200 0 1 {name=p25 sig_type=std_logic lab=dac_p_a3}
C {lab_wire.sym} 1340 -180 0 1 {name=p26 sig_type=std_logic lab=dac_p_a2}
C {lab_wire.sym} 1340 -160 0 1 {name=p27 sig_type=std_logic lab=dac_p_a1}
C {lab_wire.sym} 1340 -140 0 1 {name=p28 sig_type=std_logic lab=dac_p_a0}
C {lab_wire.sym} 1340 -120 0 1 {name=p29 sig_type=std_logic lab=dac_n_a7}
C {lab_wire.sym} 1340 -100 0 1 {name=p30 sig_type=std_logic lab=dac_n_a6}
C {lab_wire.sym} 1340 -80 0 1 {name=p31 sig_type=std_logic lab=dac_n_a5}
C {lab_wire.sym} 1340 -60 0 1 {name=p32 sig_type=std_logic lab=dac_n_a4}
C {lab_wire.sym} 1340 -40 0 1 {name=p34 sig_type=std_logic lab=dac_n_a3}
C {lab_wire.sym} 1340 -20 0 1 {name=p35 sig_type=std_logic lab=dac_n_a2}
C {lab_wire.sym} 1340 0 0 1 {name=p36 sig_type=std_logic lab=dac_n_a1}
C {lab_wire.sym} 1340 20 0 1 {name=p37 sig_type=std_logic lab=dac_n_a0}
C {lab_wire.sym} -50 -110 1 1 {name=p46 sig_type=std_logic lab=dac_p_a7}
C {lab_wire.sym} -30 -110 1 1 {name=p47 sig_type=std_logic lab=dac_p_a6}
C {lab_wire.sym} -10 -110 1 1 {name=p48 sig_type=std_logic lab=dac_p_a5}
C {lab_wire.sym} 10 -110 1 1 {name=p49 sig_type=std_logic lab=dac_p_a4}
C {lab_wire.sym} 30 -110 1 1 {name=p50 sig_type=std_logic lab=dac_p_a3}
C {lab_wire.sym} 50 -110 1 1 {name=p51 sig_type=std_logic lab=dac_p_a2}
C {lab_wire.sym} 70 -110 1 1 {name=p52 sig_type=std_logic lab=dac_p_a1}
C {lab_wire.sym} 90 -110 1 1 {name=p53 sig_type=std_logic lab=dac_p_a0}
C {lab_wire.sym} -50 60 3 1 {name=p54 sig_type=std_logic lab=dac_n_a7}
C {lab_wire.sym} -30 60 3 1 {name=p55 sig_type=std_logic lab=dac_n_a6}
C {lab_wire.sym} -10 60 3 1 {name=p56 sig_type=std_logic lab=dac_n_a5}
C {lab_wire.sym} 10 60 3 1 {name=p57 sig_type=std_logic lab=dac_n_a4}
C {lab_wire.sym} 30 60 3 1 {name=p58 sig_type=std_logic lab=dac_n_a3}
C {lab_wire.sym} 50 60 3 1 {name=p59 sig_type=std_logic lab=dac_n_a2}
C {lab_wire.sym} 70 60 3 1 {name=p60 sig_type=std_logic lab=dac_n_a1}
C {lab_wire.sym} 90 60 3 1 {name=p61 sig_type=std_logic lab=dac_n_a0}
C {lab_wire.sym} -100 -100 0 0 {name=p1 sig_type=std_logic lab=GND}
C {lab_wire.sym} -100 50 0 0 {name=p5 sig_type=std_logic lab=GND}
C {lab_wire.sym} 390 50 0 0 {name=p62 sig_type=std_logic lab=GND}
C {iopin.sym} -350 -540 2 0 {name=p63 lab=VDD}
C {iopin.sym} -350 -510 2 0 {name=p64 lab=GND}
C {ipin.sym} -350 -470 0 0 {name=p65 lab=Vref}
C {ipin.sym} -260 -220 0 0 {name=p66 lab=VIN_P}
C {ipin.sym} -270 170 0 0 {name=p67 lab=VIN_N}
C {adc_bridge1.sym} 680 -120 0 0 {name=A21
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.7
in_high=1.1
}
C {adc_bridge1.sym} 680 -150 0 0 {name=A22
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.7
in_high=1.1
}
C {lab_wire.sym} 870 -100 0 0 {name=p68 sig_type=std_logic lab=clk_d}
C {lab_wire.sym} 870 -80 0 0 {name=p69 sig_type=std_logic lab=rst_d}
C {ipin.sym} 570 -360 0 0 {name=p70 lab=clk}
C {ipin.sym} 570 -340 0 0 {name=p71 lab=rst_n}
C {opin.sym} -370 -430 0 0 {name=p72 lab=VOUTP}
C {opin.sym} -370 -390 0 0 {name=p73 lab=VOUTN}
C {dac_bridge1.sym} 1260 40 0 0 {name=A23
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 60 0 0 {name=A24
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 80 0 0 {name=A25
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 100 0 0 {name=A26
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 120 0 0 {name=A27
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 140 0 0 {name=A28
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 160 0 0 {name=A29
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 180 0 0 {name=A30
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {dac_bridge1.sym} 1260 200 0 0 {name=A31
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {opin.sym} 1380 40 0 0 {name=p33 lab=dout7}
C {opin.sym} 1380 60 0 0 {name=p38 lab=dout6}
C {opin.sym} 1380 80 0 0 {name=p39 lab=dout5}
C {opin.sym} 1380 100 0 0 {name=p40 lab=dout4}
C {opin.sym} 1380 120 0 0 {name=p41 lab=dout3}
C {opin.sym} 1380 140 0 0 {name=p42 lab=dout2}
C {opin.sym} 1380 160 0 0 {name=p43 lab=dout1}
C {opin.sym} 1380 180 0 0 {name=p44 lab=dout0}
C {opin.sym} 1380 200 0 0 {name=p45 lab=eoc}
C {dac_bridge1.sym} 1260 -300 0 0 {name=A32
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.8
}
C {lab_wire.sym} 1340 -300 0 1 {name=p15 sig_type=std_logic lab=clk_comp}
C {lab_wire.sym} 290 20 1 1 {name=p74 sig_type=std_logic lab=clk_comp}
C {sar_controller.sym} 1030 -70 0 0 {name=adut
model=dut}
